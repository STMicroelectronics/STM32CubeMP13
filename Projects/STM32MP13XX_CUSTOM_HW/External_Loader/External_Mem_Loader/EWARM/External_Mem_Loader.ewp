# IAR project External_Mem_Loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; CORE_CA7; NO_CACHE_USE; NO_MMU_USE; USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; __LOG_UART_IO_; __CP_SERIAL_BOOT__; SDCARD_FLASH
  ICCARM.CCIncludePath2: ..; ../../; ../../Inc; ../../OpenBootloader/Target; ../../OpenBootloader/App; ../../USB_Device/App; ../../USB_Device/Target; ../../OTP_Console/Inc; ../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/OpenBootloader/Core; ../../../../../../Middlewares/ST/OpenBootloader/Util; ../../../../../../Middlewares/ST/OpenBootloader/Modules/USART; ../../../../../../Middlewares/ST/OpenBootloader/Modules/USB; ../../../../../../Middlewares/ST/OpenBootloader/Modules/Mem; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Inc; C:/Program Files (x86)/GNU Arm Embedded Toolchain/10 2021.10/bin
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: External_Mem_Loader.bin
  ILINK.IlinkOutputFile: External_Mem_Loader.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_sysram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ./: startup_stm32mp135c_ca7.s
  group Application/Openbootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/Openbootloader/Target
    ../OpenBootloader/Target/: common_interface.c external_memory_interface.c iwdg_interface.c otp_interface.c ram_interface.c usart_interface.c usb_interface.c
  group Application/OTP_Console
    ../OTP_Console/Src/: otp_interface_cli.c otp_interface_cli_util.c
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_media.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User
    ../Src/: main.c otp_util.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_bsec.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_iwdg.c stm32mp13xx_hal_pcd.c stm32mp13xx_hal_pcd_ex.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_uart.c stm32mp13xx_hal_uart_ex.c stm32mp13xx_ll_rcc.c stm32mp13xx_ll_usart.c stm32mp13xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/OpenBootloader/Util
    ../../../../../Middlewares/ST/OpenBootloader/Util/: openbl_util.c
  group Middlewares/STM32_USB_Device_Library/Class/DFU/Src
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USB_Device_Library/Core/Src
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
