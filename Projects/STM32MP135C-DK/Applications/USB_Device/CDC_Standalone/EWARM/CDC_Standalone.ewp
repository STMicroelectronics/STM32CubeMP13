# IAR project CDC_Standalone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; CORE_CA7; CACHE_USE; MMU_USE; USE_HAL_DRIVER; USE_STM32MP13XX_DK; USE_IOEXPANDER; USE_USB_HS; __LOG_UART_IO_; LOGLEVEL=LOGDBG
  ICCARM.CCIncludePath2: ../../../../../../../Drivers/CMSIS/Core_A/Include; ../../USB_Device/App; ../../USB_Device/Target; ../../Core/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../../Drivers/BSP/STM32MP13xx_DISCO
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_Standalone.srec
  ILINK.IlinkOutputFile: CDC_Standalone.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_sysram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32MP135Fxx; CORE_CA7; CACHE_USE; MMU_USE; USE_HAL_DRIVER; USE_STM32MP13XX_DK; USE_IOEXPANDER; USE_USB_HS; __LOG_UART_IO_; LOGLEVEL=LOGDBG; NDEBUG
  group Application/Core
    ../Core/Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Application/EWARM
    ./: startup_stm32mp135c_ca7.s
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32MP13xx_DISCO
    ../../../../../../Drivers/BSP/STM32MP13xx_DISCO/: stm32mp13xx_disco.c stm32mp13xx_disco_bus.c stm32mp13xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_dma.c stm32mp13xx_hal_dma_ex.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_i2c.c stm32mp13xx_hal_pcd.c stm32mp13xx_hal_pcd_ex.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_tim.c stm32mp13xx_hal_tim_ex.c stm32mp13xx_hal_uart.c stm32mp13xx_hal_uart_ex.c stm32mp13xx_ll_usb.c
  group Middlewares/STM32_USB_Device_Library/Class/CDC/Inc
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h usbd_cdc_if_template.h
  group Middlewares/STM32_USB_Device_Library/Class/CDC/Src
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USB_Device_Library/Class/Core/Inc
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group Middlewares/STM32_USB_Device_Library/Class/Core/Src
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
