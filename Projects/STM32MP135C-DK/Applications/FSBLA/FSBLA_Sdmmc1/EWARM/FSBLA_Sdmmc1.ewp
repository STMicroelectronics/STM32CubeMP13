# IAR project FSBLA_Sdmmc1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; GPT_TABLE_PRESENT; USE_STM32MP13XX_DK; CORE_CA7; NO_CACHE_USE; NO_MMU_USE; USE_HAL_DRIVER; USE_FULL_ASSERT; DDR_TYPE_DDR3_4Gb
  ICCARM.CCIncludePath2: ..; ../..; ../../Inc; ../../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FSBLA_Sdmmc1.bin
  ILINK.IlinkOutputFile: FSBLA_Sdmmc1.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_sysram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/IAR/: startup_stm32mp135c_ca7.s
  group Application/User
    ../Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32MP13xx_DISCO
    ../../../../../../Drivers/BSP/STM32MP13xx_DISCO/: stm32mp13xx_disco.c stm32mp13xx_disco_bus.c stm32mp13xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_ddr.c stm32mp13xx_hal_dma.c stm32mp13xx_hal_dma_ex.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_i2c.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_sd.c stm32mp13xx_hal_sd_ex.c stm32mp13xx_ll_sdmmc.c
