# IAR project Fx_SRAM_File_Edit_Standalone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; FX_INCLUDE_USER_DEFINE_FILE; CORE_CA7; USE_STM32MP13XX_DK; CACHE_USE; MMU_USE; USE_HAL_DRIVER; USE_DDR; MCP_IOEXPANDER
  ICCARM.CCIncludePath2: ../../Core/Inc; ../../FileX/App; ../../FileX/Target; ../../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../../Middlewares/ST/threadx/common/inc/; ../../../../../../../Middlewares/ST/threadx/ports/cortex_a7/gnu/inc/; ../../../../../../../Middlewares/ST/filex/common/inc/; ../../../../../../../Middlewares/ST/filex/ports/generic/inc/; ../../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Fx_SRAM_File_Edit_Standalone.srec
  ILINK.IlinkOutputFile: Fx_SRAM_File_Edit_Standalone.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_ddr.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32MP135Fxx; FX_INCLUDE_USER_DEFINE_FILE; CORE_CA7; USE_STM32MP13XX_DK; CACHE_USE; MMU_USE; USE_HAL_DRIVER; USE_DDR; MCP_IOEXPANDER; NDEBUG
  group Application/User/Core
    ../Core/Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Application/User/FileX/App
    ../FileX/App/: app_filex.c
  group Application/User/FileX/Target
    ../FileX/Target/: fx_stm32_sram_driver.h
  group Application/User/Startup
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/IAR/: startup_stm32mp135c_ca7.s
  group Doc
    ../: README.md
  group Drivers/BSP/Components/mcp23x17
    ../../../../../../Drivers/BSP/Components/mcp23x17/: mcp23x17.c mcp23x17_reg.c
  group Drivers/BSP/STM32MP13xx_DISCO
    ../../../../../../Drivers/BSP/STM32MP13xx_DISCO/: stm32mp13xx_disco.c stm32mp13xx_disco_bus.c stm32mp13xx_disco_io.c stm32mp13xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_dma.c stm32mp13xx_hal_dma_ex.c stm32mp13xx_hal_exti.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_i2c.c stm32mp13xx_hal_i2c_ex.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_tim.c stm32mp13xx_hal_tim_ex.c stm32mp13xx_hal_uart.c stm32mp13xx_hal_uart_ex.c stm32mp13xx_ll_delayblock.c
  group Middlewares/FileX/File System/FileX/Core
    ../../../../../../Middlewares/ST/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_exFAT_entry_read.c fx_directory_exFAT_entry_write.c fx_directory_exFAT_free_search.c fx_directory_exFAT_unicode_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_fault_tolerant_add_bitmap_log.c fx_fault_tolerant_add_checksum_log.c fx_fault_tolerant_add_dir_log.c fx_fault_tolerant_add_FAT_log.c fx_fault_tolerant_apply_logs.c fx_fault_tolerant_calculate_checksum.c fx_fault_tolerant_cleanup_FAT_chain.c fx_fault_tolerant_create_log_file.c fx_fault_tolerant_enable.c fx_fault_tolerant_read_directory_sector.c fx_fault_tolerant_read_FAT.c fx_fault_tolerant_read_log_file.c fx_fault_tolerant_recover.c fx_fault_tolerant_reset_log_file.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_transaction_end.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_transaction_start.c fx_fault_tolerant_write_log_file.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_trace_event_insert.c fx_trace_event_update.c fx_trace_object_register.c fx_trace_object_unregister.c fx_unicode_directory_create.c fx_unicode_directory_entry_change.c fx_unicode_directory_entry_read.c fx_unicode_directory_rename.c fx_unicode_directory_search.c fx_unicode_file_create.c fx_unicode_file_rename.c fx_unicode_length_get.c fx_unicode_length_get_extended.c fx_unicode_name_get.c fx_unicode_name_get_extended.c fx_unicode_short_name_get.c fx_unicode_short_name_get_extended.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c fxe_unicode_directory_create.c fxe_unicode_directory_rename.c fxe_unicode_file_create.c fxe_unicode_file_rename.c fxe_unicode_name_get.c fxe_unicode_name_get_extended.c fxe_unicode_short_name_get.c fxe_unicode_short_name_get_extended.c
  group Middlewares/Interfaces/File System/FileX Internal RAM interface
    ../../../../../../Middlewares/ST/filex/common/drivers/: fx_stm32_sram_driver.c
