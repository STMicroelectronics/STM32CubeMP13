<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BSP_BasicTemplates_900MHz.ewp</path>
    </project>
    <batchBuild />
</workspace>
