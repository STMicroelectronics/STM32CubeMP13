<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HASH_SHA3384SHA3512_MDMA.ewp</path>
    </project>
    <batchBuild />
</workspace>
