<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MDMA_Mem2MemTransfer.ewp</path>
    </project>
    <batchBuild />
</workspace>
