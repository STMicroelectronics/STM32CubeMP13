<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CRYP_SAES_MDMA_ECB_CBC.ewp</path>
    </project>
    <batchBuild />
</workspace>
