<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UART_Receive_Transmit_Console.ewp</path>
    </project>
    <batchBuild />
</workspace>
