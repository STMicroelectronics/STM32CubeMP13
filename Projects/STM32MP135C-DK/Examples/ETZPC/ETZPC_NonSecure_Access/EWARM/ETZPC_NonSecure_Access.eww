<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ETZPC_NonSecure_Access.ewp</path>
    </project>
    <batchBuild />
</workspace>
