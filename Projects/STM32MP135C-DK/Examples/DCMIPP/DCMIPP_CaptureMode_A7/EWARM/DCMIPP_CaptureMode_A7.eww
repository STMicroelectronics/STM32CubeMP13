<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DCMIPP_CaptureMode_A7.ewp</path>
    </project>
    <batchBuild />
</workspace>
