# IAR project DCMIPP_SnapshotMode_A7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; MCP_IOEXPANDER; USE_CAMERA_SENSOR_GC2145; USE_STM32MP13XX_DK; USE_STMIPID02; CORE_CA7; CACHE_USE; MMU_USE; USE_DDR; USE_HAL_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..; ../../; ../../Inc; ../../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/rk043fn48h; ../../../../../../../Utilities/Fonts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: DCMIPP_SnapshotMode_A7.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_ddr.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32MP135Fxx; MCP_IOEXPANDER; USE_CAMERA_SENSOR_GC2145; USE_STM32MP13XX_DK; USE_STMIPID02; CORE_CA7; CACHE_USE; MMU_USE; USE_DDR; USE_HAL_DRIVER; USE_FULL_ASSERT; NDEBUG
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/IAR/: startup_stm32mp135c_ca7.s
  group Application/User
    ../Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/gc2145
    ../../../../../../Drivers/BSP/Components/gc2145/: gc2145.c gc2145_reg.c
  group Drivers/BSP/Components/mcp23x17
    ../../../../../../Drivers/BSP/Components/mcp23x17/: mcp23x17.c mcp23x17_reg.c
  group Drivers/BSP/Components/stmipid02
    ../../../../../../Drivers/BSP/Components/stmipid02/: stmipid02.c stmipid02_reg.c
  group Drivers/BSP/STM32MP13xx_DISCO
    ../../../../../../Drivers/BSP/STM32MP13xx_DISCO/: stm32mp13xx_disco.c stm32mp13xx_disco_bus.c stm32mp13xx_disco_camera.c stm32mp13xx_disco_io.c stm32mp13xx_disco_lcd.c stm32mp13xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_dcmipp.c stm32mp13xx_hal_dma.c stm32mp13xx_hal_dma_ex.c stm32mp13xx_hal_exti.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_i2c.c stm32mp13xx_hal_ltdc.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c
  group Utilities/Fonts
    ../../../../../../Utilities/Fonts/: font24.c
