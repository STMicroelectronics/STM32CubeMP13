# IAR project SD_Ext_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; DEBUG; CORE_CA7; NO_CACHE_USE; NO_MMU_USE; USE_HAL_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..; ../../; ../../Inc; ../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SD_Ext_loader.bin
  ILINK.IlinkOutputFile: SD_Ext_loader.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_sysram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/IAR/: startup_stm32mp135c_ca7.s
  group Application/User
    ../Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c system_stm32mp13xx_A7.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_sd.c stm32mp13xx_hal_sd_ex.c stm32mp13xx_ll_sdmmc.c
