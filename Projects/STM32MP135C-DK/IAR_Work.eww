<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Applications\FileX\Fx_SRAM_File_Edit_Standalone\EWARM\Fx_SRAM_File_Edit_Standalone.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Applications\USB_Device\CDC_Standalone\EWARM\CDC_Standalone.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\ADC\ADC_MultiChannelSingleConversion\EWARM\ADC_MultiChannelSingleConversion.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\ADC\ADC_SingleConversion_TriggerTimer_DMA\EWARM\ADC_SingleConversion_TriggerTimer_DMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\ADC\ADC_SingleConversion_TriggerTimer_DMA_Secure\EWARM\ADC_SingleConversion_TriggerTimer_DMA_Secure.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\BSP\BSP_TS_A7\EWARM\BSP_TS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRC\CRC_UserDefinedPolynomial\EWARM\CRC_UserDefinedPolynomial.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRYP\CRYP_AES_MDMA\EWARM\CRYP_AES_MDMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRYP\CRYP_SAES_MDMA_ECB_CBC\EWARM\CRYP_SAES_MDMA_ECB_CBC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRYP\CRYP_SAES_SharedKey\EWARM\CRYP_SAES_SharedKey.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRYP\CRYP_SAES_WrapKey\EWARM\CRYP_SAES_WrapKey.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\CRYP\CRYP_TDESModes\EWARM\CRYP_TDESModes.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DCMIPP\DCMIPP_CaptureMode_A7\EWARM\DCMIPP_CaptureMode_A7.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DCMIPP\DCMIPP_SnapshotMode_A7\EWARM\DCMIPP_SnapshotMode_A7.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DDR\DDR_Init\EWARM\DDR_Init.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DMA\DMA_FIFOMode\EWARM\DMA_FIFOMode.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DMA\DMA_FIFOMode_Secure\EWARM\DMA_FIFOMode_Secure.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\DTS\DTS_GetTemperature\EWARM\DTS_GetTemperature.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\ETZPC\ETZPC_NonSecure_Access\EWARM\ETZPC_NonSecure_Access.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\FDCAN\FDCAN_Loopback\EWARM\FDCAN_Loopback.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\GPIO\GPIO_EXTI\EWARM\GPIO_EXTI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\HASH\HASH_SHA3384SHA3512_MDMA\EWARM\HASH_SHA3384SHA3512_MDMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\I2C\I2C_TwoBoards_ComIT\EWARM\I2C_TwoBoards_ComIT.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\IWDG\IWDG_WindowMode\EWARM\IWDG_WindowMode.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\LPTIM\LPTIM_PulseCounter\EWARM\LPTIM_PulseCounter.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\LTDC\LTDC_Display_2Layers\EWARM\LTDC_Display_2Layers.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\MDMA\MDMA_Mem2MemTransfer\EWARM\MDMA_Mem2MemTransfer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\MDMA\MDMA_Mem2MemTransfer_Secure\EWARM\MDMA_Mem2MemTransfer_Secure.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\PKA\PKA_ECCDoubleBaseLadder\EWARM\PKA_ECDDoubleBaseLadder.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\PKA\PKA_ECDSA_Sign\EWARM\PKA_ECDSA_Sign.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\PWR\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\PWR\PWR_STANDBY_RTC\EWARM\PWR_STANDBY_RTC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\PWR\PWR_STOP_RTC\EWARM\PWR_STOP_RTC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\RNG\RNG_MultiRNG\EWARM\RNG_MultiRNG.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\RTC\RTC_Alarm\EWARM\RTC_Alarm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\RTC\RTC_Tamper\EWARM\RTC_Tamper.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\RTC\RTC_TimeStamp\EWARM\RTC_TimeStamp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\SD\SD_ReadWrite_DMALinkedList\EWARM\SD_ReadWrite_DMALinkedList.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\SPI\SPI_FullDuplex_ComDMA_Master\EWARM\SPI_FullDuplex_ComDMA_Master.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\SPI\SPI_FullDuplex_ComDMA_Slave\EWARM\SPI_FullDuplex_ComDMA_Slave.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\SPI\SPI_FullDuplex_ComIT_Master\EWARM\SPI_FullDuplex_ComIT_Master.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\SPI\SPI_FullDuplex_ComIT_Slave\EWARM\SPI_FullDuplex_ComIT_Slave.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\TIM\TIM_DMABurst\EWARM\TIM_DMABurst.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\UART\UART_Receive_Transmit_Console\EWARM\UART_Receive_Transmit_Console.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\UART\UART_TwoBoards_ComDMA\EWARM\UART_TwoBoards_ComDMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\UART\UART_TwoBoards_ComIT\EWARM\UART_TwoBoards_ComIT.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Examples\USART\USART_SlaveMode_DMA\EWARM\USART_SlaveMode_DMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Templates\BSP_BasicTemplates\EWARM\BSP_BasicTemplates.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Templates\BSP_BasicTemplates_900MHz\EWARM\BSP_BasicTemplates_900MHz.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All_build</name>
            <member>
                <project>ADC_MultiChannelSingleConversion</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ADC_MultiChannelSingleConversion</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>ADC_SingleConversion_TriggerTimer_DMA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ADC_SingleConversion_TriggerTimer_DMA</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>ADC_SingleConversion_TriggerTimer_DMA_Secure</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ADC_SingleConversion_TriggerTimer_DMA_Secure</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>BSP_BasicTemplates</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>BSP_BasicTemplates</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>BSP_BasicTemplates_900MHz</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>BSP_BasicTemplates_900MHz</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>BSP_TS</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>BSP_TS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CDC_Standalone</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CDC_Standalone</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRC_UserDefinedPolynomial</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRC_UserDefinedPolynomial</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRYP_AES_MDMA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRYP_AES_MDMA</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRYP_SAES_MDMA_ECB_CBC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRYP_SAES_MDMA_ECB_CBC</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRYP_SAES_SharedKey</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRYP_SAES_SharedKey</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRYP_SAES_WrapKey</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRYP_SAES_WrapKey</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>CRYP_TDESModes</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>CRYP_TDESModes</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DCMIPP_CaptureMode_A7</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DCMIPP_CaptureMode_A7</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DCMIPP_SnapshotMode_A7</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DCMIPP_SnapshotMode_A7</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DDR_Init</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DDR_Init</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DMA_FIFOMode</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DMA_FIFOMode</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DMA_FIFOMode_Secure</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DMA_FIFOMode_Secure</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>DTS_GetTemperature</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>DTS_GetTemperature</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>ETZPC_NonSecure_Access</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>ETZPC_NonSecure_Access</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>FDCAN_Loopback</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>FDCAN_Loopback</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>Fx_SRAM_File_Edit_Standalone</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Fx_SRAM_File_Edit_Standalone</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>GPIO_EXTI</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>GPIO_EXTI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HASH_SHA3384SHA3512_MDMA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HASH_SHA3384SHA3512_MDMA</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_ComIT</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_ComIT</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>IWDG_WindowMode</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>IWDG_WindowMode</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>LPTIM_PulseCounter</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>LPTIM_PulseCounter</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>LTDC_Display_2Layers</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>LTDC_Display_2Layers</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>MDMA_Mem2MemTransfer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>MDMA_Mem2MemTransfer</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>MDMA_Mem2MemTransfer_Secure</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>MDMA_Mem2MemTransfer_Secure</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>PKA_ECDDoubleBaseLadder</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>PKA_ECDDoubleBaseLadder</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>PKA_ECDSA_Sign</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>PKA_ECDSA_Sign</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>PWR_STANDBY</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>PWR_STANDBY</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>PWR_STANDBY_RTC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>PWR_STANDBY_RTC</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>PWR_STOP_RTC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>PWR_STOP_RTC</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>RNG_MultiRNG</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>RNG_MultiRNG</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>RTC_Alarm</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>RTC_Alarm</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>RTC_Tamper</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>RTC_Tamper</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>RTC_TimeStamp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>RTC_TimeStamp</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>SD_ReadWrite_DMALinkedList</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>SD_ReadWrite_DMALinkedList</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComDMA_Master</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComDMA_Master</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComDMA_Slave</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComDMA_Slave</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComIT_Master</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComIT_Master</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComIT_Slave</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>SPI_FullDuplex_ComIT_Slave</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>TIM_DMABurst</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>TIM_DMABurst</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>UART_Receive_Transmit_Console</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>UART_Receive_Transmit_Console</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_ComDMA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_ComDMA</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_ComIT</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_ComIT</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>USART_SlaveMode_DMA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>USART_SlaveMode_DMA</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
